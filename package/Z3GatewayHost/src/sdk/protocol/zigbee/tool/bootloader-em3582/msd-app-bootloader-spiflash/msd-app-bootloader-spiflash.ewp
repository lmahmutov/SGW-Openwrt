# IAR project msd-app-bootloader-spiflash.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_NULL; BOARD_DEV0680ETM; BOARD_HEADER="../../platform/base/hal/micro/cortexm3/em35x/board/dev0680etm.h"; CORTEXM3_EMBER_MICRO; MAX_RADIO_POWER=0; BTL_HAS_SERIAL; BOOTLOADER; SPI_FLASH_SC1; MSD_BOOTLOADER; EEPROM_USES_SHUTDOWN_CONTROL; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; USB_MSD; BOOTLOADER_USB; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\stack\; ..\..\..\..\..\platform\base\hal\; ..\..\..\..\..\platform\base\; ../../../../../platform/CMSIS/Include; ../../../../../platform/Device/SiliconLabs/em358x/Include/; ../../../../../platform/radio/rail_lib/plugin; ../../../../../platform/radio/rail_lib/plugin/coexistence/common; ../../../../../platform/radio/rail_lib/plugin/coexistence/hal/em3xx/; ../../../../../platform/base/hal/micro/cortexm3/common; ../../../../../platform/base/hal/plugin; ../../../../../platform/radio/rail_lib/plugin; ../../../app/util; ../../../../../platform/base/lwip/; ../../../../../platform/base/lwip/src/include/; ../../../../../platform/base/lwip/contrib/port/FreeRTOS/EM358X/; ../../../../../platform/base/lwip/src/include/ipv4/; ../../../../../platform/base/lwip/src/include/ipv6/; ../../../app/test/micrium_cfg/; ../../../../../platform/micrium_os; ../../../../../platform/micrium_os/bsp/include; ../../../../../platform/micrium_os/kernel/include; ../../../../../platform/micrium_os/common/include; ../../../../../platform/micrium_os/bsp/siliconlabs/generic/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EM3582; PHY_NULL; BOARD_DEV0680ETM; BOARD_HEADER="../../platform/base/hal/micro/cortexm3/em35x/board/dev0680etm.h"; CORTEXM3_EMBER_MICRO; MAX_RADIO_POWER=0; BTL_HAS_SERIAL; BOOTLOADER; SPI_FLASH_SC1; MSD_BOOTLOADER; EEPROM_USES_SHUTDOWN_CONTROL; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; USB_MSD; BOOTLOADER_USB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: msd-app-bootloader-spiflash.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: msd-app-bootloader-spiflash.out
  ILINK.IlinkConfigDefines: HEADER_SIZE=256; BOOTLOADER=1; FLASH_SIZE=1M; RAM_SIZE=256K
  ILINK.IlinkIcfFile: ../../../../../platform/base/hal/micro/cortexm3/em35x/em3582/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../platform/base/hal/micro/cortexm3/common/: app-bootloader-custom.c spiflash-class1.c
    ../../../../../platform/base/hal/micro/cortexm3/bootloader/: app-bootloader-em3xx.c bootloader-gpio.c cstartup-iar-boot-entry.s79 cstartup-iar-boot.c spiflash-low-level.c
    ../../../../../platform/base/hal/micro/generic/: crc.c mem-util.c random.c
    ../../../../../platform/base/hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../../../platform/base/hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../build/msd-app-bootloader-library-cortexm3-iarboot-em3582-null/: msd-app-bootloader-library.a
    ../../../../../platform/base/hal/micro/cortexm3/usb/msd/: msdd.c msddmedia.c
